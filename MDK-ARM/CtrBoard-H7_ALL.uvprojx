# Keil uVision project CtrBoard-H7_ALL.uvprojx, settings and files
target CtrBoard-H7_ALL (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrBoard-H7_ALL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_HAL_DRIVER,ARM_MATH_CM7,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../CMSIS/Core/Inc;../CMSIS/DSP/Inc/dsp;../CMSIS/DSP/Inc;../CMSIS/DSP/PrivateInclude;../User/Algorithm/inc;../User/App/inc;../User/Bsp/inc;../User/Start/Inc;..\User\UI\Inc
  asm include: ../Core/Inc;..\Core\Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Bsp
    ../User/Bsp/inc/: BMI088reg.h BMI088driver.h BMI088Middleware.h bsp_buzzer.h bsp_dwt.h bsp_imu_pwm.h can_bsp.h DJI_Motor.h DM_Motor.h Image_RX.h NIMING.h Referee.h RUI_DBUS.h RUI_MATH.h VOFA.h ws2812.h Circular_Buffer.h VT13.h
    ../User/Bsp/: BMI088driver.c BMI088Middleware.c bsp_buzzer.c bsp_dwt.c bsp_imu_pwm.c can_bsp.c DJI_Motor.c DM_Motor.c Image_RX.c NIMING.c Referee.c RUI_DBUS.c RUI_MATH.c VOFA.c ws2812.c Circular_Buffer.c VT13.c
  group Algorithm
    ../User/Algorithm/: Arm_Control.c controller.c CRC_DJI.c kalman_filter.c pid_temp.c QuaternionEKF.c Revolve.c user_lib.c
    ../User/Algorithm/inc/: Arm_Control.h controller.h CRC_DJI.h kalman_filter.h pid_temp.h QuaternionEKF.h Revolve.h user_lib.h
  group App
    ../User/App/: Gimbal_Task.c IMU_Task.c Monitor_Task.c K3debug_Task.c DM_test.c Move_Task.c Usart.Task.c One_Click_Task.c HID_Control.c
    ../User/App/inc/: Gimbal_Task.h IMU_Task.h Monitor_Task.h K3debug_Task.h DM_test.h Move_Task.h Usart_Task.h One_Click_Task.h HID_Control.h
  group Start
    ../User/Start/: All_Init.c WHW_IRQN.c
    ../User/Start/Inc/: All_Init.h MY_Define.h WHW_IRQN.h Motors.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c adc.c
    ../Core/Inc/: adc.h
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group CMSIS
    ../CMSIS/DSP/Src/BasicMathFunctions/: BasicMathFunctions.c
    ../CMSIS/DSP/Src/BayesFunctions/: BayesFunctions.c
    ../CMSIS/DSP/Src/CommonTables/: CommonTables.c
    ../CMSIS/DSP/Src/ComplexMathFunctions/: ComplexMathFunctions.c
    ../CMSIS/DSP/Src/ControllerFunctions/: ControllerFunctions.c
    ../CMSIS/DSP/Src/DistanceFunctions/: DistanceFunctions.c
    ../CMSIS/DSP/Src/FastMathFunctions/: FastMathFunctions.c
    ../CMSIS/DSP/Src/FilteringFunctions/: FilteringFunctions.c
    ../CMSIS/DSP/Src/InterpolationFunctions/: InterpolationFunctions.c
    ../CMSIS/DSP/Src/MatrixFunctions/: MatrixFunctions.c
    ../CMSIS/DSP/Src/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../CMSIS/DSP/Src/StatisticsFunctions/: StatisticsFunctions.c
    ../CMSIS/DSP/Src/SupportFunctions/: SupportFunctions.c
    ../CMSIS/DSP/Src/SVMFunctions/: SVMFunctions.c
    ../CMSIS/DSP/Src/TransformFunctions/: TransformFunctions.c
    ../CMSIS/DSP/Src/WindowFunctions/: WindowFunctions.c
